# Keil uVision project project.uvprojx, settings and files
target stm32f103ze (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32FLib\CMSIS\CoreSupport;..\STM32FLib\CMSIS\DeviceSupport;..\STM32FLib\INC;..\SRC;..\SRC\STM_sys;..\SRC\USER;..\SRC\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../STM32FLib/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../STM32FLib/CMSIS/CoreSupport/: core_cm3.c
    ../STM32FLib/CMSIS/DeviceSupport/: system_stm32f10x.c
  group FWLIB
    ../STM32FLib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../SRC/USER/: main.c
    ../SRC/STM_sys/: stm32f10x_it.c
  group DRIVER
    ../SRC/Driver/gpio/: gpio.c
    ../SRC/Driver/usart/: uart.c
    ../SRC/Driver/I2C/: i2c.c
    ../SRC/Driver/SPI/: spi.c
    ../SRC/Driver/adc/: adc.c
    ../SRC/Driver/dac/: DAC.c
    ../SRC/Driver/timer/: timer.c
    ../SRC/Driver/led/: led.c
